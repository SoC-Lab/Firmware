# Keil uVision project throttle_stm32f072.uvprojx, settings and files
target STM32F072RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072RB
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: MBED_CONF_RTOS_PRESENT DEVICE_CRC=1 DEVICE_SERIAL=1 __MBED__=1 DEVICE_SERIAL_FC=1 CMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" MBED_ROM_START=0x8000000 TARGET_STM32F072RB TARGET_CORTEX_M DEVICE_USTICKER=1 TARGET_CORTEX DEVICE_ANALOGOUT=1 DEVICE_PORTOUT=1 DEVICE_I2C=1 MBED_TRAP_ERRORS_ENABLED=1 ARM_MATH_CM0 CMSIS_VECTAB_VIRTUAL DEVICE_RTC=1 TRANSACTION_QUEUE_SIZE_SPI=2 MBED_ROM_SIZE=0x20000 TARGET_FAMILY_STM32 TARGET_LIKE_MBED DEVICE_PORTIN=1 DEVICE_SPI_ASYNCH=1 __CMSIS_RTOS MBED_BUILD_TIMESTAMP=1551362794.5299401 __ASSERT_MSG DEVICE_STDIO_MESSAGES=1 DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 DEVICE_FLASH=1 TARGET_STM MBED_RAM_SIZE=0x4000 __CORTEX_M0 DEVICE_SPISLAVE=1 TARGET_FF_ARDUINO MBED_RAM_START=0x20000000 TARGET_NUCLEO_F072RB TARGET_M0 TOOLCHAIN_ARM TARGET_LIKE_CORTEX_M0 __MBED_CMSIS_RTOS_CM DEVICE_SERIAL_ASYNCH=1 DEVICE_I2CSLAVE=1 COMPONENT_NSPE=1 TOOLCHAIN_ARM_STD DEVICE_LPTICKER=1 TARGET_DEBUG DEVICE_SLEEP=1 TARGET_STM32F0 DEVICE_CAN=1 DEVICE_PORTINOUT=1 MBED_DEBUG DEVICE_SPI=1 COMPONENT_PSA_SRV_EMUL=1 COMPONENT_PSA_SRV_IMPL=1 DEVICE_PWMOUT=1 TARGET_FF_MORPHO DEVICE_I2C_ASYNCH=1 NDEBUG MBED_FAULT_HANDLER_DISABLED
  c misc: -c --split_sections -g --no_depend_system_headers --md --gnu --cpu=Cortex-M0 --restrict --no_rtti --apcs=interwork --brief_diagnostics --multibyte_chars --preinclude=mbed_config.h --feedback=link_feedback
  c include: ..\..\;..\..\mbed-os;..\..\mbed-os\cmsis;..\..\mbed-os\cmsis\TARGET_CORTEX_M;..\..\mbed-os\components;..\..\mbed-os\components\802.15.4_RF;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver\atmel-rf-driver;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver\mcr20a-rf-driver;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver\stm-s2lp-rf-driver;..\..\mbed-os\components\wifi;..\..\mbed-os\components\wifi\esp8266-driver;..\..\mbed-os\components\wifi\esp8266-driver\ESP8266;..\..\mbed-os\drivers;..\..\mbed-os\events;..\..\mbed-os\events\equeue;..\..\mbed-os\features;..\..\mbed-os\features\cellular;..\..\mbed-os\features\cellular\framework;..\..\mbed-os\features\cellular\framework\API;..\..\mbed-os\features\cellular\framework\AT;..\..\mbed-os\features\cellular\framework\common;..\..\mbed-os\features\cellular\framework\device;..\..\mbed-os\features\cellular\framework\targets;..\..\mbed-os\features\cellular\framework\targets\GEMALTO;..\..\mbed-os\features\cellular\framework\targets\GEMALTO\CINTERION;..\..\mbed-os\features\cellular\framework\targets\MultiTech;..\..\mbed-os\features\cellular\framework\targets\MultiTech\DragonflyNano;..\..\mbed-os\features\cellular\framework\targets\MultiTech\DragonflyNano\PPP;..\..\mbed-os\features\cellular\framework\targets\QUECTEL;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\BC95;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\BG96;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\UG96;..\..\mbed-os\features\cellular\framework\targets\TELIT;..\..\mbed-os\features\cellular\framework\targets\TELIT\HE910;..\..\mbed-os\features\cellular\framework\targets\UBLOX;..\..\mbed-os\features\cellular\framework\targets\UBLOX\AT;..\..\mbed-os\features\cellular\framework\targets\UBLOX\PPP;..\..\mbed-os\features\device_key;..\..\mbed-os\features\device_key\source;..\..\mbed-os\features\frameworks;..\..\mbed-os\features\frameworks\greentea-client;..\..\mbed-os\features\frameworks\greentea-client\greentea-client;..\..\mbed-os\features\frameworks\mbed-client-cli;..\..\mbed-os\features\frameworks\mbed-client-cli\mbed-client-cli;..\..\mbed-os\features\frameworks\mbed-client-randlib;..\..\mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib;..\..\mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib\platform;..\..\mbed-os\features\frameworks\mbed-coap;..\..\mbed-os\features\frameworks\mbed-coap\mbed-coap;..\..\mbed-os\features\frameworks\mbed-coap\source;..\..\mbed-os\features\frameworks\mbed-coap\source\include;..\..\mbed-os\features\frameworks\mbed-trace;..\..\mbed-os\features\frameworks\mbed-trace\mbed-trace;..\..\mbed-os\features\frameworks\nanostack-libservice;..\..\mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice;..\..\mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice\platform;..\..\mbed-os\features\frameworks\unity;..\..\mbed-os\features\frameworks\unity\unity;..\..\mbed-os\features\frameworks\utest;..\..\mbed-os\features\frameworks\utest\utest;..\..\mbed-os\features\lorawan;..\..\mbed-os\features\lorawan\lorastack;..\..\mbed-os\features\lorawan\lorastack\mac;..\..\mbed-os\features\lorawan\lorastack\phy;..\..\mbed-os\features\lorawan\system;..\..\mbed-os\features\lwipstack;..\..\mbed-os\features\lwipstack\lwip;..\..\mbed-os\features\lwipstack\lwip-sys;..\..\mbed-os\features\lwipstack\lwip-sys\arch;..\..\mbed-os\features\lwipstack\lwip\src;..\..\mbed-os\features\lwipstack\lwip\src\include;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip\priv;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip\prot;..\..\mbed-os\features\lwipstack\lwip\src\include\netif;..\..\mbed-os\features\lwipstack\lwip\src\include\netif\ppp;..\..\mbed-os\features\lwipstack\lwip\src\include\netif\ppp\polarssl;..\..\mbed-os\features\mbedtls;..\..\mbed-os\features\mbedtls\inc;..\..\mbed-os\features\mbedtls\inc\mbedtls;..\..\mbed-os\features\mbedtls\inc\psa;..\..\mbed-os\features\mbedtls\platform;..\..\mbed-os\features\mbedtls\platform\inc;..\..\mbed-os\features\mbedtls\targets\TARGET_STM;..\..\mbed-os\features\nanostack;..\..\mbed-os\features\nanostack\coap-service;..\..\mbed-os\features\nanostack\coap-service\coap-service;..\..\mbed-os\features\nanostack\coap-service\source;..\..\mbed-os\features\nanostack\coap-service\source\include;..\..\mbed-os\features\nanostack\mbed-mesh-api;..\..\mbed-os\features\nanostack\mbed-mesh-api\mbed-mesh-api;..\..\mbed-os\features\nanostack\mbed-mesh-api\source;..\..\mbed-os\features\nanostack\mbed-mesh-api\source\include;..\..\mbed-os\features\nanostack\nanostack-hal-mbed-cmsis-rtos;..\..\mbed-os\features\nanostack\nanostack-interface;..\..\mbed-os\features\nanostack\sal-stack-nanostack;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop\platform;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\source;..\..\mbed-os\features\nanostack\sal-stack-nanostack\nanostack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\nanostack\platform;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Bootstraps;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Fragmentation;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\IPHC_Decode;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\MAC;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Mesh;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\ND;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\NVM;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Thread;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\ws;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\BorderRouter;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Common_Protocols;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Core;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Core\include;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\DHCPv6_Server;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\DHCPv6_client;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\IEEE802_15_4;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\virtual_rf;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MLE;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MPL;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE\Include;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\RPL;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\Common;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\PANA;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\TLS;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Neighbor_cache;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Trickle;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\blacklist;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\etx;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fhss;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fnv_hash;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\load_balance;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mac_neighbor_table;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\compiler;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\cpu;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\dns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\mdns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\poll;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\serial;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mle_service;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\nd_proxy;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\pan_blacklist;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\utils;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\whiteboard;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\configs;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\configs\base;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\ipv6_stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libDHCPv6;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libNET;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libNET\src;..\..\mbed-os\features\netsocket;..\..\mbed-os\features\netsocket\cellular;..\..\mbed-os\features\netsocket\cellular\generic_modem_driver;..\..\mbed-os\features\nfc;..\..\mbed-os\features\nfc\acore;..\..\mbed-os\features\nfc\acore\acore;..\..\mbed-os\features\nfc\controllers;..\..\mbed-os\features\nfc\nfc;..\..\mbed-os\features\nfc\nfc\ndef;..\..\mbed-os\features\nfc\nfc\ndef\common;..\..\mbed-os\features\nfc\stack;..\..\mbed-os\features\nfc\stack\ndef;..\..\mbed-os\features\nfc\stack\platform;..\..\mbed-os\features\nfc\stack\tech;..\..\mbed-os\features\nfc\stack\tech\iso7816;..\..\mbed-os\features\nfc\stack\tech\isodep;..\..\mbed-os\features\nfc\stack\tech\type4;..\..\mbed-os\features\nfc\stack\transceiver;..\..\mbed-os\features\nfc\stack\transceiver\pn512;..\..\mbed-os\features\storage;..\..\mbed-os\features\storage\blockdevice;..\..\mbed-os\features\storage\filesystem;..\..\mbed-os\features\storage\filesystem\fat;..\..\mbed-os\features\storage\filesystem\fat\ChaN;..\..\mbed-os\features\storage\filesystem\littlefs;..\..\mbed-os\features\storage\filesystem\littlefs\littlefs;..\..\mbed-os\features\storage\kvstore;..\..\mbed-os\features\storage\kvstore\conf;..\..\mbed-os\features\storage\kvstore\filesystemstore;..\..\mbed-os\features\storage\kvstore\global_api;..\..\mbed-os\features\storage\kvstore\kv_map;..\..\mbed-os\features\storage\kvstore\securestore;..\..\mbed-os\features\storage\kvstore\tdbstore;..\..\mbed-os\features\storage\nvstore;..\..\mbed-os\features\storage\nvstore\source;..\..\mbed-os\features\storage\system_storage;..\..\mbed-os\hal;..\..\mbed-os\hal\storage_abstraction;..\..\mbed-os\platform;..\..\mbed-os\rtos;..\..\mbed-os\rtos\TARGET_CORTEX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx4;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Config;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source;..\..\mbed-os\targets\TARGET_STM;..\..\mbed-os\targets\TARGET_STM\TARGET_STM32F0;..\..\mbed-os\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F072RB;..\..\mbed-os\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F072RB\device;..\..\mbed-os\targets\TARGET_STM\TARGET_STM32F0\device;..\..\Library
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DCMSIS_VECTAB_VIRTUAL,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-D__CORTEX_M0,-DARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\mbed-os\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F072RB\device\TOOLCHAIN_ARM_STD\stm32f072rb.sct
  link misc: --show_full_path --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_BOOT_STACK_SIZE=1024" --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_RAM_SIZE=0x5000" --feedback=link_feedback --feedback_type=unused,noiw
  group Application
    ../: main.cpp Throttle.cpp
    ../../Library/: Packet.cpp
  group mbed-os
    ../../mbed-os/platform/: ATCmdParser.cpp CallChain.cpp CThunkBase.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_poll.cpp mbed_retarget.cpp mbed_sdk_boot.c mbed_stats.c mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp Stream.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os1.c
    ../../mbed-os/rtos/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp RtosTimer.cpp Semaphore.cpp ThisThread.cpp Thread.cpp
    ../../mbed-os/targets/TARGET_STM/: gpio_api.c gpio_irq_api.c hal_tick_overrides.c lp_ticker.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c serial_api.c sleep.c us_ticker.c rtc_api.c
    ../../mbed-os/hal/: LowPowerTickerWrapper.cpp mbed_critical_section_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c
    ../../mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/TOOLCHAIN_ARM_STD/: mbed_boot_arm_std.c
    ../../mbed-os/cmsis/TARGET_CORTEX_M/: mbed_fault_handler.c mbed_tz_context.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    ../../mbed-os/drivers/: RawSerial.cpp Serial.cpp SerialBase.cpp TableCRC.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../mbed-os/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F072RB/device/TOOLCHAIN_ARM_STD/: startup_stm32f072xb.S
    ../../mbed-os/targets/TARGET_STM/TARGET_STM32F0/device/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_ll_dma.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c system_stm32f0xx.c stm32f0xx_ll_exti.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_ll_rtc.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M0/: irq_cm0.S
    ../../mbed-os/targets/TARGET_STM/TARGET_STM32F0/: gpio_irq_device.c serial_device.c pwmout_device.c
    ../../mbed-os/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F072RB/device/: system_clock.c cmsis_nvic.c
    ../../mbed-os/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F072RB/: PeripheralPins.c
