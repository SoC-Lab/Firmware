# Keil uVision project throttle_xilinx_cm1.uvprojx, settings and files
target xilinx-cm1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: xilinx-cm1
  AfterMake: make_hex.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: MBED_CONF_RTOS_PRESENT  CORTEX_M1 ARTY_CM1 TARGET_ZEDBOARD __ASSERT_MSG DEVICE_PORTOUT=1 TARGET_CORTEX_M DEVICE_USTICKER=1 TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_CORTEX __MBED__=1 DEVICE_PORTIN=1 TARGET_M1 __CMSIS_RTOS __MBED_CMSIS_RTOS_CM MBED_FAULT_HANDLER_DISABLED NDEBUG DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 DEVICE_I2C
  c misc: --gnu --preinclude=..\..\mbed_config.h --feedback=link_feedback
  c include: ..\..\mbed-os\targets\TARGET_Xilinx;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device;..\..\;..\..\mbed-os;..\..\mbed-os\cmsis;..\..\mbed-os\cmsis\TARGET_CORTEX_M;..\..\mbed-os\components;..\..\mbed-os\components\802.15.4_RF;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver\atmel-rf-driver;..\..\mbed-os\components\802.15.4_RF\atmel-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver\mcr20a-rf-driver;..\..\mbed-os\components\802.15.4_RF\mcr20a-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver\source;..\..\mbed-os\components\802.15.4_RF\stm-s2lp-rf-driver\stm-s2lp-rf-driver;..\..\mbed-os\components\wifi;..\..\mbed-os\components\wifi\esp8266-driver;..\..\mbed-os\components\wifi\esp8266-driver\ESP8266;..\..\mbed-os\drivers;..\..\mbed-os\events;..\..\mbed-os\events\equeue;..\..\mbed-os\features;..\..\mbed-os\features\cellular;..\..\mbed-os\features\cellular\framework;..\..\mbed-os\features\cellular\framework\API;..\..\mbed-os\features\cellular\framework\AT;..\..\mbed-os\features\cellular\framework\common;..\..\mbed-os\features\cellular\framework\device;..\..\mbed-os\features\cellular\framework\targets;..\..\mbed-os\features\cellular\framework\targets\GEMALTO;..\..\mbed-os\features\cellular\framework\targets\GEMALTO\CINTERION;..\..\mbed-os\features\cellular\framework\targets\MultiTech;..\..\mbed-os\features\cellular\framework\targets\MultiTech\DragonflyNano;..\..\mbed-os\features\cellular\framework\targets\MultiTech\DragonflyNano\PPP;..\..\mbed-os\features\cellular\framework\targets\QUECTEL;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\BC95;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\BG96;..\..\mbed-os\features\cellular\framework\targets\QUECTEL\UG96;..\..\mbed-os\features\cellular\framework\targets\TELIT;..\..\mbed-os\features\cellular\framework\targets\TELIT\HE910;..\..\mbed-os\features\cellular\framework\targets\UBLOX;..\..\mbed-os\features\cellular\framework\targets\UBLOX\AT;..\..\mbed-os\features\cellular\framework\targets\UBLOX\PPP;..\..\mbed-os\features\device_key;..\..\mbed-os\features\device_key\source;..\..\mbed-os\features\frameworks;..\..\mbed-os\features\frameworks\greentea-client;..\..\mbed-os\features\frameworks\greentea-client\greentea-client;..\..\mbed-os\features\frameworks\mbed-client-cli;..\..\mbed-os\features\frameworks\mbed-client-cli\mbed-client-cli;..\..\mbed-os\features\frameworks\mbed-client-randlib;..\..\mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib;..\..\mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib\platform;..\..\mbed-os\features\frameworks\mbed-coap;..\..\mbed-os\features\frameworks\mbed-coap\mbed-coap;..\..\mbed-os\features\frameworks\mbed-coap\source;..\..\mbed-os\features\frameworks\mbed-coap\source\include;..\..\mbed-os\features\frameworks\mbed-trace;..\..\mbed-os\features\frameworks\mbed-trace\mbed-trace;..\..\mbed-os\features\frameworks\nanostack-libservice;..\..\mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice;..\..\mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice\platform;..\..\mbed-os\features\frameworks\unity;..\..\mbed-os\features\frameworks\unity\unity;..\..\mbed-os\features\frameworks\utest;..\..\mbed-os\features\frameworks\utest\utest;..\..\mbed-os\features\lorawan;..\..\mbed-os\features\lorawan\lorastack;..\..\mbed-os\features\lorawan\lorastack\mac;..\..\mbed-os\features\lorawan\lorastack\phy;..\..\mbed-os\features\lorawan\system;..\..\mbed-os\features\lwipstack;..\..\mbed-os\features\lwipstack\lwip;..\..\mbed-os\features\lwipstack\lwip-sys;..\..\mbed-os\features\lwipstack\lwip-sys\arch;..\..\mbed-os\features\lwipstack\lwip\src;..\..\mbed-os\features\lwipstack\lwip\src\include;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip\priv;..\..\mbed-os\features\lwipstack\lwip\src\include\lwip\prot;..\..\mbed-os\features\lwipstack\lwip\src\include\netif;..\..\mbed-os\features\lwipstack\lwip\src\include\netif\ppp;..\..\mbed-os\features\lwipstack\lwip\src\include\netif\ppp\polarssl;..\..\mbed-os\features\mbedtls;..\..\mbed-os\features\mbedtls\inc;..\..\mbed-os\features\mbedtls\inc\mbedtls;..\..\mbed-os\features\mbedtls\inc\psa;..\..\mbed-os\features\mbedtls\platform;..\..\mbed-os\features\mbedtls\platform\inc;..\..\mbed-os\features\mbedtls\targets\TARGET_STM;..\..\mbed-os\features\nanostack;..\..\mbed-os\features\nanostack\coap-service;..\..\mbed-os\features\nanostack\coap-service\coap-service;..\..\mbed-os\features\nanostack\coap-service\source;..\..\mbed-os\features\nanostack\coap-service\source\include;..\..\mbed-os\features\nanostack\mbed-mesh-api;..\..\mbed-os\features\nanostack\mbed-mesh-api\mbed-mesh-api;..\..\mbed-os\features\nanostack\mbed-mesh-api\source;..\..\mbed-os\features\nanostack\mbed-mesh-api\source\include;..\..\mbed-os\features\nanostack\nanostack-hal-mbed-cmsis-rtos;..\..\mbed-os\features\nanostack\nanostack-interface;..\..\mbed-os\features\nanostack\sal-stack-nanostack;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop\platform;..\..\mbed-os\features\nanostack\sal-stack-nanostack-eventloop\source;..\..\mbed-os\features\nanostack\sal-stack-nanostack\nanostack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\nanostack\platform;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Bootstraps;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Fragmentation;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\IPHC_Decode;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\MAC;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Mesh;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\ND;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\NVM;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Thread;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\ws;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\BorderRouter;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Common_Protocols;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Core;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Core\include;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\DHCPv6_Server;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\DHCPv6_client;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\IEEE802_15_4;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\virtual_rf;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MLE;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\MPL;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE\Include;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\RPL;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\Common;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\PANA;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Security\TLS;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Neighbor_cache;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Trickle;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\blacklist;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\etx;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fhss;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fnv_hash;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\load_balance;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mac_neighbor_table;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\compiler;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\cpu;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\dns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\mdns;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\poll;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\serial;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mle_service;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\nd_proxy;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\pan_blacklist;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\utils;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\whiteboard;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\configs;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\configs\base;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\ipv6_stack;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libDHCPv6;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libNET;..\..\mbed-os\features\nanostack\sal-stack-nanostack\source\libNET\src;..\..\mbed-os\features\netsocket;..\..\mbed-os\features\netsocket\cellular;..\..\mbed-os\features\netsocket\cellular\generic_modem_driver;..\..\mbed-os\features\nfc;..\..\mbed-os\features\nfc\acore;..\..\mbed-os\features\nfc\acore\acore;..\..\mbed-os\features\nfc\controllers;..\..\mbed-os\features\nfc\nfc;..\..\mbed-os\features\nfc\nfc\ndef;..\..\mbed-os\features\nfc\nfc\ndef\common;..\..\mbed-os\features\nfc\stack;..\..\mbed-os\features\nfc\stack\ndef;..\..\mbed-os\features\nfc\stack\platform;..\..\mbed-os\features\nfc\stack\tech;..\..\mbed-os\features\nfc\stack\tech\iso7816;..\..\mbed-os\features\nfc\stack\tech\isodep;..\..\mbed-os\features\nfc\stack\tech\type4;..\..\mbed-os\features\nfc\stack\transceiver;..\..\mbed-os\features\nfc\stack\transceiver\pn512;..\..\mbed-os\features\storage;..\..\mbed-os\features\storage\blockdevice;..\..\mbed-os\features\storage\filesystem;..\..\mbed-os\features\storage\filesystem\fat;..\..\mbed-os\features\storage\filesystem\fat\ChaN;..\..\mbed-os\features\storage\filesystem\littlefs;..\..\mbed-os\features\storage\filesystem\littlefs\littlefs;..\..\mbed-os\features\storage\kvstore;..\;..\..\mbed-os\features\storage\kvstore\conf;..\..\mbed-os\features\storage\kvstore\filesystemstore;..\..\mbed-os\features\storage\kvstore\global_api;..\..\mbed-os\features\storage\kvstore\kv_map;..\..\mbed-os\features\storage\kvstore\securestore;..\..\mbed-os\features\storage\kvstore\tdbstore;..\..\mbed-os\features\storage\nvstore;..\..\mbed-os\features\storage\nvstore\source;..\..\mbed-os\features\storage\system_storage;..\..\mbed-os\hal;..\..\mbed-os\hal\storage_abstraction;..\..\mbed-os\platform;..\..\mbed-os\rtos;..\..\mbed-os\rtos\TARGET_CORTEX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx4;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Config;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source;..\..\Library;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\include;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\iic_v3_4\src;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\tmrctr_v4_4\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler --feedback=link_feedback --feedback_type=unused,noiw
  group application
    ../../Library/: Packet.cpp
    ../application/: Throttle.cpp main.cpp
  group mbed-os
    ../../mbed-os/targets/TARGET_Xilinx/: gpio_api.c us_ticker.c serial_api.c i2c_api.c
    ../../mbed-os/hal/: mbed_gpio.c mbed_critical_section_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_sleep_manager.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/: system_ARTY_CM1.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/TOOLCHAIN_ARM_STD/: startup_ARTY_CM1.s
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/gpio_v4_3/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/standalone_v6_6/src/: outbyte.c xil_assert.c print.c
    ../../mbed-os/platform/: mbed_critical.c mbed_assert.c mbed_board.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_poll.cpp mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp Stream.cpp ATCmdParser.cpp CallChain.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c CThunkBase.cpp
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
    ../../mbed-os/drivers/: Serial.cpp SerialBase.cpp TimerEvent.cpp Timer.cpp Timeout.cpp Ticker.cpp I2C.cpp
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/iic_v3_4/src/: xiic.c xiic_dyn_master.c xiic_g.c xiic_intr.c xiic_l.c xiic_master.c xiic_multi_master.c xiic_options.c xiic_selftest.c xiic_sinit.c xiic_slave.c xiic_stats.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/tmrctr_v4_4/src/: xtmrctr.c xtmrctr_g.c xtmrctr_intr.c xtmrctr_l.c xtmrctr_options.c xtmrctr_selftest.c xtmrctr_sinit.c xtmrctr_stats.c
  group rtos
    ../../mbed-os/rtos/TARGET_CORTEX/TOOLCHAIN_ARM_STD/: mbed_boot_arm_std.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rtx_kernel.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c
    ../../mbed-os/rtos/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp RtosTimer.cpp Semaphore.cpp ThisThread.cpp Thread.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os1.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M0/: irq_cm0.S
target xilinx-cm1_sim (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: xilinx-cm1_sim
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: SIM_BUILD CORTEX_M1 ARTY_CM1 __ASSERT_MSG DEVICE_PORTOUT=1 TARGET_CORTEX_M TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_CORTEX __MBED__=1 DEVICE_PORTIN=1 TARGET_M1 __CMSIS_RTOS __MBED_CMSIS_RTOS_CM MBED_FAULT_HANDLER_DISABLED DEVICE_SERIAL NDEBUG DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 DEVICE_I2C
  c misc: as above
  c include: ..\..\mbed-os\targets\TARGET_Xilinx;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device;..\..\mbed-os\drivers;..\..\mbed-os;..\..\mbed-os\cmsis\TARGET_CORTEX_M;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\include;..\..\mbed-os\platform;..\..\mbed-os\rtos\TARGET_CORTEX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\Include;..\..\;..\..\mbed-os\rtos;..\..\mbed-os\rtos\TARGET_CORTEX\rtx4;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Config;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source;..\..\mbed-os\hal;..\..\mbed-os\cmsis;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\tmrctr_v4_4\src;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\iic_v3_4\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: as above
