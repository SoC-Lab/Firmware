# Keil uVision project ecu_xilinx_cm1.uvprojx, settings and files
target xilinx-cm1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: xilinx-cm1
  AfterMake: make_hex.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 TARGET_ZEDBOARD __ASSERT_MSG DEVICE_PORTOUT=1 TARGET_CORTEX_M DEVICE_USTICKER=1 TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_CORTEX __MBED__=1 DEVICE_PORTIN=1 TARGET_M1 __CMSIS_RTOS __MBED_CMSIS_RTOS_CM MBED_FAULT_HANDLER_DISABLED NDEBUG DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 DEVICE_I2C
  c misc: --gnu --preinclude=..\..\mbed_config.h --feedback=link_feedback
  c include: ..\..\mbed-os\targets\TARGET_Xilinx;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device;..\..\mbed-os\drivers;..\..\mbed-os;..\..\mbed-os\cmsis\TARGET_CORTEX_M;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\include;..\..\mbed-os\platform;..\..\mbed-os\rtos\TARGET_CORTEX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Include;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\Include;..\..\;..\..\mbed-os\rtos;..\..\mbed-os\rtos\TARGET_CORTEX\rtx4;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Config;..\..\mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source;..\..\mbed-os\hal;..\..\mbed-os\cmsis;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\tmrctr_v4_4\src;..\..\mbed-os\targets\TARGET_Xilinx\TARGET_XC7Z020\device\standalone_bsp\Cortex_M1_0\libsrc\iic_v3_4\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --entry=Reset_Handler --feedback=link_feedback --feedback_type=unused,noiw
  group application
    ../: main.cpp
  group mbed-os
    ../../mbed-os/targets/TARGET_Xilinx/: gpio_api.c us_ticker.c serial_api.c i2c_api.c
    ../../mbed-os/hal/: mbed_gpio.c mbed_critical_section_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_sleep_manager.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/: system_ARTY_CM1.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/TOOLCHAIN_ARM_STD/: startup_ARTY_CM1.s
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/gpio_v4_3/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/standalone_v6_6/src/: outbyte.c xil_assert.c print.c
    ../../mbed-os/platform/: mbed_critical.c mbed_assert.c mbed_board.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_poll.cpp mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp Stream.cpp ATCmdParser.cpp CallChain.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c CThunkBase.cpp
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
    ../../mbed-os/drivers/: Serial.cpp SerialBase.cpp TimerEvent.cpp Timer.cpp Timeout.cpp Ticker.cpp I2C.cpp
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/iic_v3_4/src/: xiic.c xiic_dyn_master.c xiic_g.c xiic_intr.c xiic_l.c xiic_master.c xiic_multi_master.c xiic_options.c xiic_selftest.c xiic_sinit.c xiic_slave.c xiic_stats.c
    ../../mbed-os/targets/TARGET_Xilinx/TARGET_XC7Z020/device/standalone_bsp/Cortex_M1_0/libsrc/tmrctr_v4_4/src/: xtmrctr.c xtmrctr_g.c xtmrctr_intr.c xtmrctr_l.c xtmrctr_options.c xtmrctr_selftest.c xtmrctr_sinit.c xtmrctr_stats.c
  group rtos
    ../../mbed-os/rtos/TARGET_CORTEX/TOOLCHAIN_ARM_STD/: mbed_boot_arm_std.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rtx_kernel.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c
    ../../mbed-os/rtos/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp RtosTimer.cpp Semaphore.cpp ThisThread.cpp Thread.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp
    ../../mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os1.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    ../../mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_M0/: irq_cm0.S
target xilinx-cm1_sim (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: xilinx-cm1_sim
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: SIM_BUILD CORTEX_M1 ARTY_CM1 __ASSERT_MSG DEVICE_PORTOUT=1 TARGET_CORTEX_M TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_CORTEX __MBED__=1 DEVICE_PORTIN=1 TARGET_M1 __CMSIS_RTOS __MBED_CMSIS_RTOS_CM MBED_FAULT_HANDLER_DISABLED DEVICE_SERIAL NDEBUG DEVICE_SERIAL=1 DEVICE_STDIO_MESSAGES=1 DEVICE_I2C
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: as above
